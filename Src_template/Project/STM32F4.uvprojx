# Keil uVision project STM32F4.uvprojx, settings and files
target STM32F4 (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32F407ZG STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.17.0
  cpu: IRAM(0x20000000,0x20000) IRAM2(0x10000000,0x10000) IROM(0x08000000,0x100000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: STM32F4
  c flags: Optim=3 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: STM32F40_41xxx,USE_STDPERIPH_DRIVER
  c include: ..\FWLIB\inc;..\HARDWARE;..\USER;..\SYSTERM;..\CORE;..\FATFS;..\HARDWARE\MPU6050;..\HARDWARE\MPU6050\eMPL;..\u8g2_csrc
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group USER
    ../USER/: system_stm32f4xx.c main.c stm32f4xx_it.c pid.c Kalman.c control.c cJSON.c datasave.c
  group FWLIB
    ../FWLIB/src/: misc.c stm32f4xx_adc.c stm32f4xx_dac.c stm32f4xx_dbgmcu.c stm32f4xx_exti.c stm32f4xx_flash.c stm32f4xx_flash_ramfunc.c stm32f4xx_gpio.c stm32f4xx_i2c.c stm32f4xx_pwr.c stm32f4xx_rcc.c stm32f4xx_rtc.c stm32f4xx_sdio.c stm32f4xx_spi.c stm32f4xx_syscfg.c stm32f4xx_tim.c stm32f4xx_usart.c stm32f4xx_dma.c stm32f4xx_dma2d.c
  group HARDWARE
    ../HARDWARE/: led.c key.c oled.c spi.c w25qxx.c sdio_sdcard.c servo.c adc.c motor.c ch451key.c tm1650key.c track.c sw_i2c.c gw_grayscale_sensor.c
    ../HARDWARE/MPU6050/: mpu6050.c mpuexti.c mpuiic.c
    ../HARDWARE/MPU6050/eMPL/: inv_mpu.c inv_mpu_dmp_motion_driver.c
  group CORE
    ../CORE/: startup_stm32f40_41xxx.s
  group SYSTEM
    ../SYSTERM/: delay.c sys.c usart.c timer.c stmflash.c
  group u8g2
    ../u8g2_csrc/: mui.c mui_u8g2.c u8g2_box.c u8g2_buffer.c u8g2_button.c u8g2_circle.c u8g2_cleardisplay.c u8g2_d_memory.c u8g2_bitmap.c u8g2_d_setup.c u8g2_font.c u8g2_fonts.c u8g2_hvline.c u8g2_input_value.c u8g2_intersection.c u8g2_kerning.c u8g2_line.c u8g2_ll_hvline.c u8g2_message.c u8g2_polygon.c u8g2_selection_list.c u8g2_setup.c u8log.c u8log_u8g2.c u8log_u8x8.c u8x8_8x8.c u8x8_byte.c u8x8_cad.c u8x8_capture.c u8x8_d_ssd1306_48x64.c u8x8_d_ssd1306_64x32.c u8x8_d_ssd1306_64x48.c u8x8_d_ssd1306_72x40.c u8x8_d_ssd1306_96x16.c u8x8_d_ssd1306_96x40.c u8x8_d_ssd1306_128x32.c u8x8_d_ssd1306_128x64_noname.c u8x8_d_ssd1306_2040x16.c u8x8_debounce.c u8x8_display.c u8x8_fonts.c u8x8_gpio.c u8x8_input_value.c u8x8_message.c u8x8_selection_list.c u8x8_setup.c u8x8_string.c u8x8_u8toa.c u8x8_u16toa.c u8g2_init.c
  group fatfs
    ../FATFS/: diskio.c fatfs.c ff.c ffsystem.c ffunicode.c
